# IAR project EXTI_demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\###WORK###\STM8\+++\EXTI\inc; D:\###WORK###\STM8\+++\EXTI\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: EXTI_demo.srec
  ILINK.IlinkOutputFile: EXTI_demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group inc
    inc/: delay.h stm8l15x.h STM8L15x_clk.h stm8l15x_conf.h STM8L15x_exti.h STM8L15x_gpio.h STM8L15x_itc.h stm8l15x_usart.h
  group src
    src/: delay.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_usart.c
