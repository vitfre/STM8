# IAR project main.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\###WORK###\STM8\+++\lcd\inc; D:\###WORK###\STM8\+++\lcd\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: main.srec
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: LCD.c LCD.h main.c
