<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\inc\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm8l15x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm8L15x_clk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm8L15x_gpio.h</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <file>
      <name>$PROJ_DIR$\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\stm8l15x_gpio.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\LCD.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\LCD.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


