# IAR project Backup of LCD_test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\Work\STM8\STM8L-Discovery\LCD\inc; D:\Work\STM8\STM8L-Discovery\LCD\src
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: LCD_test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group inc
    inc/: delay.h stm8l15x.h stm8L15x_clk.h stm8l15x_conf.h stm8L15x_gpio.h
  group src
    src/: stm8l15x_clk.c stm8l15x_gpio.c
