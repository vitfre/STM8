# IAR project Backup of 1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105S6 STM8S105S6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x150
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ; inc\; LIB\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.hex
  ILINK.IlinkOutputFile: 1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    inc/: init.h timebase.h
  group LIB/inc
    LIB/inc/: stm8s.h stm8s_clk.h stm8s_conf.h stm8s_gpio.h stm8s_iwdg.h stm8s_tim4.h stm8s_type.h stm8s_uart2.h
  group LIB/src
    LIB/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group src
    src/: init.c main.c timebase.c
