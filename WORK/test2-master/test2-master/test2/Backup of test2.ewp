# IAR project Backup of test2.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: test2.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group lib/inc
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group lib/src
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_exti.c stm8l15x_gpio.c
