# IAR project Backup of tiggo_mirror.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: STM8S/inc; 
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: tiggo_mirror.bin
  ILINK.IlinkOutputFile: locker.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c platform_config.h stm8s_conf.h
  group inc
    ./: beep.h delay.h ds18b20.h eemem.h led_driver.h mirror.h stm8s_it.h
  group src
    ./: beep.c delay.c ds18b20.c eemem.c led_driver.c mirror.c stm8s_it.c
  group STM8S/inc
    STM8S/inc/: stm8s.h stm8s_beep.h stm8s_clk.h stm8s_flash.h stm8s_gpio.h stm8s_spi.h stm8s_tim2.h stm8s_tim4.h stm8s_uart1.h
  group STM8S/src
    STM8S/src/: stm8s_beep.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
